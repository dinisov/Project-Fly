// const int stimPin =  6;      // stimulus: on (pulsed) during stimulus boutsconst int stimPin =  6;      // stimulus: on (pulsed) during stimulus bouts
const int FramePin =  4;      // indicator: on (constant) during stimulus bouts
// const int CamFramePin =  5;
// const int initPin = 7;
const int ShutterPin = 2;

//GLOBAL VARIABLES:
// boolean lastReading;
// boolean buttonState = HIGH;
boolean lastButtonState = HIGH;
// int randomSequence[10] ;

int stimulusTime = 800;
int recordingTime = 2000;

void setup()
{

  //open serial channel
  Serial.begin(9600);

  //this stops execution until serial port receives an 'S' for start
  while(Serial.read() != 'S'){}

  //weirdly, setting the pinMode triggers the pin being set
  pinMode(FramePin, OUTPUT);
  pinMode(ShutterPin, OUTPUT);
  digitalWrite(FramePin, LOW);
  digitalWrite(ShutterPin, LOW);

}

void programRun(unsigned long initTime) {

	//just in case a 'S' was leftover from a previous run
	Serial.print("E");

	//give Octave time to start up after opening the serial channel
	delay(5000);

	//leave this here it is important when doing 2P experiments in stimulus mode
	// digitalWrite(FramePin, HIGH);
	// delay(50);
	// digitalWrite(FramePin, LOW);
	// delay(1000);

	int nTriggers = 1000;

	for (int i = 0; i < nTriggers; i++) {

		//stimulus phase (shutter closed)
		digitalWrite(FramePin, LOW);
		digitalWrite(ShutterPin, LOW);
		delay(50);//small delay to make sure shutter is closed before turning on projector
		Serial.print("S");//this starts the next bout of stimuli
		delay(stimulusTime);//show some stimuli (e.g. train of 5 stimuli)

		//recording part (shutter open)
		digitalWrite(ShutterPin, HIGH);//open shutter
		delay(20);//enough time for shutter to be fully open
		digitalWrite(FramePin, HIGH);//start recording
		delay(recordingTime);
		
	}

	// digitalWrite(ShutterPin, LOW);//close shutter
	digitalWrite(FramePin, LOW);//open shutter

	Serial.print("E");

}

void loop() {

  if (lastButtonState == HIGH) {
    programRun(millis());
  }
  lastButtonState = LOW;

}